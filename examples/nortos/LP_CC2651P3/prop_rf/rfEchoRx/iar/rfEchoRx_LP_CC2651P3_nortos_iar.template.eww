<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/rfEchoRx_LP_CC2651P3_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>