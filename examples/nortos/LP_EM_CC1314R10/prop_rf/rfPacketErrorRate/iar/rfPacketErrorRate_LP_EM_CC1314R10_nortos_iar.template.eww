<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/rfPacketErrorRate_LP_EM_CC1314R10_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>