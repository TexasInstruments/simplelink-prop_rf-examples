# IAR project rfOADServer_LP_EM_CC1354P10_1_tirtos7_iar.ewp, settings and files
configuration Debug_BIM (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
configuration Release_BIM (ARM)
  as the first configuration, except:
configuration Debug_MCUBoot (ARM, debug)
  as the first configuration, except:
configuration Release_MCUBoot (ARM)
  as the first configuration, except:
  group (top)
    ./: rfOADServer_LP_EM_CC1354P10_1_tirtos7_iar.ipcf SysConfig_Generated_Files.ipcf
  group RF OAD Server
    oad/native_oad/: oad_config.h
