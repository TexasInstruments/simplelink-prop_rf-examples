# IAR project rfSynchronizedPacketRx_LP_EM_CC1354P10_1_freertos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: rfSynchronizedPacketRx_LP_EM_CC1354P10_1_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
