# IAR project rfOADClientIntFlashPApp_CC1352P1_LAUNCHXL_tirtos7_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: rfOADClientIntFlashPApp_CC1352P1_LAUNCHXL_tirtos7_iar.ipcf SysConfig_Generated_Files.ipcf
