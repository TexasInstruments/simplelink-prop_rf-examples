<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/rfPacketErrorRate_CC1352P_2_LAUNCHXL_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>