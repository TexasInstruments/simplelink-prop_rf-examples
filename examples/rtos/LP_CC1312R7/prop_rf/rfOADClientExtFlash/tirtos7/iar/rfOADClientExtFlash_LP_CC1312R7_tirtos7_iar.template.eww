<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/rfOADClientExtFlash_LP_CC1312R7_tirtos7_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>