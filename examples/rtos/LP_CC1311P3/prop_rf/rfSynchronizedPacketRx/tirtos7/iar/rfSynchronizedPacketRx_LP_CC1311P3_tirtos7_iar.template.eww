<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/rfSynchronizedPacketRx_LP_CC1311P3_tirtos7_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>