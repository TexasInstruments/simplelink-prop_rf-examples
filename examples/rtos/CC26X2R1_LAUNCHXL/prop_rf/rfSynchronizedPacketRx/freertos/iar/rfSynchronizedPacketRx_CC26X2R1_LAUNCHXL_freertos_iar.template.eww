<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/rfSynchronizedPacketRx_CC26X2R1_LAUNCHXL_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>